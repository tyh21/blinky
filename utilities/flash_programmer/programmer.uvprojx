# Keil uVision project programmer.uvprojx, settings and files
target DA14585_jtag (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: jtag_programmer_585 +hex
  AfterMake: fromelf --bincombined --output=".\Out_jtag_585\@L.bin"  "!L"
  c flags: Optim=4 uC99=1
  c define: __NON_BLE_EXAMPLE__
  c misc: --thumb -c --bss_threshold=0 --preinclude da1458x_config_basic.h --feedback=".\unused_jtag_585.txt"
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\arch\main;.\..\..\sdk\platform\core_modules\nvds\api;..\..\sdk\platform\include\CMSIS\5.6.0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x1b00
  memory RVCT9: RAM 0x81b00 size 0x500
  scatter file: .\startup\programmer_jtag_585.sct
  link misc: --datacompressor=off --feedback=".\unused_jtag_585.txt"
  group Startup Files
    ../../sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ../../sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group Source Files
    ./src/: peripherals.c programmer.c
    ../../third_party/crc32/: crc32.c
    ./../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ./../../sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../sdk/platform/driver/gpio/: gpio.c
    ../../sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../sdk/platform/driver/dma/: dma.c
    ../../sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ../../sdk/platform/driver/i2c/: i2c.c
    ../../sdk/platform/driver/uart/: uart.c
    ../../sdk/platform/driver/syscntl/: syscntl.c
    ../../sdk/platform/driver/timer/: timer0.c
    ../../sdk/platform/arch/main/: arch_system.c
    ../../sdk/platform/utilities/otp_cs/: otp_cs.c
  group Include Files
    ./include/: user_periph_setup.h programmer.h version.h da1458x_config_basic.h
    ./../../sdk/platform/driver/gpio/: gpio.h
    ./../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../sdk/platform/driver/spi/: spi.h
    ./../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk/platform/driver/hw_otpc/: hw_otpc.h
target DA14585_uart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: flash_programmer_585 +hex
  AfterMake: fromelf --bincombined --output=".\Out_uart_585\@L.bin"  "!L"
  c flags: Optim=4 uC99=1
  c define: USE_UART __NON_BLE_EXAMPLE__
  c misc: --thumb -c --bss_threshold=0 --preinclude da1458x_config_basic.h --feedback=".\unused_uart_585.txt"
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\core_modules\nvds\api;.\..\..\sdk\platform\arch\main;..\..\sdk\platform\include\CMSIS\5.6.0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xa000
  scatter file: .\startup\programmer_uart_585.sct
  link misc: --datacompressor=off --feedback=".\unused_uart_585.txt"
target DA14531_jtag (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: jtag_programmer_531 +hex
  AfterMake: fromelf --bincombined --output=".\Out_jtag_531\@L.bin"  "!L"
  c flags: Optim=4 uC99=1
  c define: __DA14531__ __NON_BLE_EXAMPLE__
  c misc: --thumb -c --bss_threshold=0 --preinclude da1458x_config_basic.h --feedback=".\unused_jtag_531.txt"
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\driver\adc;.\..\..\sdk\platform\arch\main;.\..\..\sdk\platform\core_modules\nvds\api;.\..\..\sdk\platform\utilities\otp_cs;.\..\..\sdk\platform\core_modules\rf\api;..\..\sdk\platform\include\CMSIS\5.6.0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_jtag_531.sct
  link misc: --datacompressor=off --feedback=".\unused_jtag_531.txt"
target DA14531_uart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: flash_programmer_531 +hex
  AfterMake: fromelf --bincombined --output=".\Out_uart_531\@L.bin"  "!L"
  c flags: Optim=4 uC99=1
  c define: __DA14531__ USE_UART CFG_UART_ONE_WIRE_SUPPORT __NON_BLE_EXAMPLE__
  c misc: --thumb -c --bss_threshold=0 --preinclude da1458x_config_basic.h --feedback=".\unused_uart_531.txt"
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\driver\adc;.\..\..\sdk\platform\arch\main;.\..\..\sdk\platform\core_modules\nvds\api;.\..\..\sdk\platform\core_modules\rf\api;.\..\..\sdk\platform\utilities\otp_cs;..\..\sdk\platform\include\CMSIS\5.6.0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_uart_531.sct
  link misc: --datacompressor=off --feedback=".\unused_uart_531.txt"
